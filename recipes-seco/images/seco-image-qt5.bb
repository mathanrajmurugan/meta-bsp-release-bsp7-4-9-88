DESCRIPTION = "Freescale Image - Adds Qt5"
LICENSE = "MIT"

require recipes-seco/images/seco-image-qt5-validation-imx.bb
